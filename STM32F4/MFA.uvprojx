# Keil uVision project MFA.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MFA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: .\STM32F4xx_StdPeriph_Driver\inc;E:\MFA;.\CONTROL;.\PWM;.\UART;.\DELAY;.\ENC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx_it.c
  group Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_tim.c
  group DELAY
    ./DELAY/: delay.c delay.h
  group PWM
    ./PWM/: pwm.c pwm.h
  group ENC
    ./ENC/: enc.c enc.h
  group UART
    ./UART/: uart.c uart.h
  group CONTROL
    ./CONTROL/: control.c control.h
software components: CMSIS:CORE 5.3.0
